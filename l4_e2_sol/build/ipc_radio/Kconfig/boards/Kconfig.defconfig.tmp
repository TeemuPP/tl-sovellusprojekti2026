## l4_e2_sol/build/ipc_radio/Kconfig/boards/Kconfig.defconfig.tmp
```kconfig
# Load Zephyr board defconfig descriptions.
osource "C:/ncs/v3.4.1/zephyr/boards/nordic/nrf5340dk/Kconfig.defconfig"
```
